options:
  parameters:
    generate_options: qt_gui
    id: gps_nav_message_decoder_v1
    output_language: python
    title: gps_nav_message_decoder_v1
  states: {}

blocks:
- name: delta_f
  id: variable_qtgui_range
  parameters:
    label: delta_f
    orient: Qt.Horizontal
    start: '-20000'
    step: '250'
    stop: '+20000'
    value: '-8340'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: svid
  id: variable
  parameters:
    value: '20'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: samp_rate//1000
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: delta_f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: subframes.raw
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/memyselfandi/projects/gnss-sdr-files/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN.dat
    repeat: 'True'
    type: short
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '6'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: gnss_acquisition_and_tracking_0
  id: gnss_acquisition_and_tracking
  parameters:
    debug_port: 'False'
    dll_bw_coarse: '4.0'
    dll_bw_fine: '2.0'
    identifier: svid
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: '40.0'
    pll_bw_fine: '35.0'
    sampling_freq: samp_rate
  states: {}
- name: gnss_ca_code_generator_1
  id: gnss_ca_code_generator
  parameters:
    domain: gnss.CA_CODE_DOMAIN_TIME
    sampling_freq: samp_rate
    svid: svid
    type: complex
    vlen: '1'
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_nav_message_decoder_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '20'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_signal_normalizer_0
  id: gnss_signal_normalizer
  parameters:
    itype: s16
    otype: fc32
    resolution: '12'
    vlen: '1'
  states: {}
- name: gnss_type_converter_0_0_0
  id: gnss_type_converter
  parameters:
    itype: fc64
    otype: fc32
    vlen: '1'
  states: {}
- name: gps_acquisition_0
  id: gps_acquisition
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: vector_length
    min: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: vector_length
    srate: samp_rate
    type: float
    ymax: '100000000000000000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: '1000'
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_argmax_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_file_source_0, '0', gnss_signal_normalizer_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_short_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0, '0']
- [blocks_throttle_0, '0', gps_acquisition_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_ca_sybmols_to_nav_bits_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_type_converter_0_0_0, '0']
- [gnss_ca_code_generator_1, '0', blocks_stream_to_vector_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0, '0', gnss_nav_message_decoder_0, '0']
- [gnss_nav_message_decoder_0, '0', blocks_null_sink_0_0_0, '0']
- [gnss_signal_normalizer_0, '0', blocks_throttle_0, '0']
- [gnss_type_converter_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
