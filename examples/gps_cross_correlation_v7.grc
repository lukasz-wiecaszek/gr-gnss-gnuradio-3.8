options:
  parameters:
    generate_options: qt_gui
    id: gps_cross_correlation_v7
    output_language: python
    title: gps_cross_correlation_v7
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/memyselfandi/projects/gnuradio/gr-gps/examples/signal.dat
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '6'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gnss_acquisition_and_tracking_0
  id: gnss_acquisition_and_tracking
  parameters:
    identifier: '1'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    identifier: '11'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    identifier: '20'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    identifier: '32'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    sampling_freq: samp_rate
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_nav_message_decoder_0
  id: gnss_nav_message_decoder
  parameters:
    filename: subframes_prn_1.dat
  states: {}
- name: gnss_nav_message_decoder_0_0
  id: gnss_nav_message_decoder
  parameters:
    filename: subframes_prn_11.dat
  states: {}
- name: gnss_nav_message_decoder_0_0_0
  id: gnss_nav_message_decoder
  parameters:
    filename: subframes_prn_20.dat
  states: {}
- name: gnss_nav_message_decoder_0_0_0_0
  id: gnss_nav_message_decoder
  parameters:
    filename: subframes_prn_32.dat
  states: {}
- name: gnss_pseudoranges_decoder_0
  id: gnss_pseudoranges_decoder
  parameters:
    num_inputs: '4'
  states: {}
- name: gps_acquisition_0
  id: gps_acquisition
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0_0_0, '0']
- [blocks_throttle_0, '0', gps_acquisition_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_ca_sybmols_to_nav_bits_0, '0']
- [gnss_acquisition_and_tracking_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0, '0']
- [gnss_acquisition_and_tracking_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0, '0', gnss_nav_message_decoder_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0, '0', gnss_nav_message_decoder_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0_0, '0', gnss_nav_message_decoder_0_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0_0_0, '0', gnss_nav_message_decoder_0_0_0_0, '0']
- [gnss_nav_message_decoder_0, '0', gnss_pseudoranges_decoder_0, '0']
- [gnss_nav_message_decoder_0_0, '0', gnss_pseudoranges_decoder_0, '1']
- [gnss_nav_message_decoder_0_0_0, '0', gnss_pseudoranges_decoder_0, '2']
- [gnss_nav_message_decoder_0_0_0_0, '0', gnss_pseudoranges_decoder_0, '3']
- [gnss_pseudoranges_decoder_0, '0', blocks_null_sink_0_0_0_0, '0']

metadata:
  file_format: 1
