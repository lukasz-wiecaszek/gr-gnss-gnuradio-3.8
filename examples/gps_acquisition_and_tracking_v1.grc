options:
  parameters:
    generate_options: qt_gui
    id: gps_acquisition_and_tracking_v1
    output_language: python
    title: gps_acquisition_and_tracking_v1
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: vector_length
    value: '0'
  states: {}
- name: delta_f
  id: variable_qtgui_range
  parameters:
    label: delta_f
    orient: Qt.Horizontal
    start: '-20000'
    step: '250'
    stop: '+20000'
    value: '-8500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: svid
  id: variable
  parameters:
    value: '20'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: samp_rate//1000
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: delta_f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/memyselfandi/projects/gnss-sdr-files/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN.dat
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_length)
  states: {}
- name: gnss_ca_code_generator_1
  id: gnss_ca_code_generator
  parameters:
    domain: gnss.CA_CODE_DOMAIN_TIME
    sampling_freq: samp_rate
    svid: svid
    type: complex
    vlen: '1'
  states: {}
- name: gps_acquisition_0
  id: gps_acquisition
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: vector_length
    srate: samp_rate
    type: float
    ymax: '10000000000000000'
    ymin: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', gps_acquisition_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle_0_0_0, '0', blocks_delay_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [gnss_ca_code_generator_1, '0', blocks_throttle_0_0_0, '0']

metadata:
  file_format: 1
