options:
  parameters:
    generate_options: qt_gui
    id: gps_rft_v1
    output_language: python
    title: gps_rft_v1
  states: {}

blocks:
- name: dll_bw_coarse
  id: variable
  parameters:
    value: '4.0'
  states: {}
- name: dll_bw_fine
  id: variable
  parameters:
    value: '2.0'
  states: {}
- name: pll_bw_coarse
  id: variable
  parameters:
    value: '40.0'
  states: {}
- name: pll_bw_fine
  id: variable
  parameters:
    value: '35.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/memyselfandi/projects/gnss-sdr-files/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN.dat
    repeat: 'True'
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gnss_acquisition_and_tracking_0
  id: gnss_acquisition_and_tracking
  parameters:
    debug_port: 'False'
    dll_bw_coarse: dll_bw_coarse
    dll_bw_fine: dll_bw_fine
    identifier: '1'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: pll_bw_coarse
    pll_bw_fine: pll_bw_fine
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    debug_port: 'False'
    dll_bw_coarse: dll_bw_coarse
    dll_bw_fine: dll_bw_fine
    identifier: '11'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: pll_bw_coarse
    pll_bw_fine: pll_bw_fine
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    debug_port: 'False'
    dll_bw_coarse: dll_bw_coarse
    dll_bw_fine: dll_bw_fine
    identifier: '20'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: pll_bw_coarse
    pll_bw_fine: pll_bw_fine
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    debug_port: 'True'
    dll_bw_coarse: dll_bw_coarse
    dll_bw_fine: dll_bw_fine
    identifier: '32'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: pll_bw_coarse
    pll_bw_fine: pll_bw_fine
    sampling_freq: samp_rate
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_geojson_file_sink_1
  id: gnss_geojson_file_sink
  parameters:
    filename: '"default"'
  states: {}
- name: gnss_nav_message_decoder_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '1'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_nav_message_decoder_0_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '11'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_nav_message_decoder_0_0_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '20'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_nav_message_decoder_0_0_0_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '32'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_pseudoranges_decoder_0
  id: gnss_pseudoranges_decoder
  parameters:
    add_velocity_outputs: 'False'
    identifier0: '1'
    identifier1: '11'
    identifier2: '20'
    identifier3: '32'
    identifier4: '-1'
    identifier5: '-1'
    identifier6: '-1'
    identifier7: '-1'
    navigation_system0: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system1: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system2: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system3: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system4: gnss.NAVIGATION_SYSTEM_UNDEFINED
    navigation_system5: gnss.NAVIGATION_SYSTEM_UNDEFINED
    navigation_system6: gnss.NAVIGATION_SYSTEM_UNDEFINED
    navigation_system7: gnss.NAVIGATION_SYSTEM_UNDEFINED
    num_inputs: '4'
  states: {}
- name: gnss_pvt_0
  id: gnss_pvt
  parameters:
    num_inputs: '4'
    skip_zeros: 'True'
  states: {}
- name: gnss_rft_0
  id: gnss_rft
  parameters:
    rft: gnss.RFT_ECEF_TO_GCS
  states: {}
- name: gnss_signal_normalizer_0
  id: gnss_signal_normalizer
  parameters:
    itype: s16
    otype: fc32
    resolution: '12'
    vlen: '1'
  states: {}
- name: gnss_type_converter_0_0
  id: gnss_type_converter
  parameters:
    itype: fc64
    otype: fc32
    vlen: '1'
  states: {}
- name: gnss_type_converter_0_0_0
  id: gnss_type_converter
  parameters:
    itype: fc64
    otype: fc32
    vlen: '1'
  states: {}
- name: gps_acquisition_0
  id: gps_acquisition
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: '1000'
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '200'
    srate: '1000'
    type: float
    ymax: 1023000+20
    ymin: 1023000-20
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_file_source_0, '0', gnss_signal_normalizer_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0_0_0, '0']
- [blocks_throttle_0, '0', gps_acquisition_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_ca_sybmols_to_nav_bits_0, '0']
- [gnss_acquisition_and_tracking_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0_0, '0', gnss_type_converter_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0_0, '1', gnss_type_converter_0_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0, '0', gnss_nav_message_decoder_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0, '0', gnss_nav_message_decoder_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0_0, '0', gnss_nav_message_decoder_0_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0_0_0, '0', gnss_nav_message_decoder_0_0_0_0, '0']
- [gnss_nav_message_decoder_0, '0', gnss_pseudoranges_decoder_0, '0']
- [gnss_nav_message_decoder_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_nav_message_decoder_0_0, '0', gnss_pseudoranges_decoder_0, '1']
- [gnss_nav_message_decoder_0_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_nav_message_decoder_0_0_0, '0', gnss_pseudoranges_decoder_0, '2']
- [gnss_nav_message_decoder_0_0_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0_0_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_nav_message_decoder_0_0_0_0, '0', gnss_pseudoranges_decoder_0, '3']
- [gnss_nav_message_decoder_0_0_0_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0_0_0_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_pseudoranges_decoder_0, '0', gnss_pvt_0, '0']
- [gnss_pseudoranges_decoder_0, '1', gnss_pvt_0, '1']
- [gnss_pseudoranges_decoder_0, '2', gnss_pvt_0, '2']
- [gnss_pseudoranges_decoder_0, '3', gnss_pvt_0, '3']
- [gnss_pvt_0, '0', gnss_rft_0, '0']
- [gnss_rft_0, '0', gnss_geojson_file_sink_1, '0']
- [gnss_signal_normalizer_0, '0', blocks_throttle_0, '0']
- [gnss_type_converter_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [gnss_type_converter_0_0_0, '0', blocks_complex_to_imag_0, '0']

metadata:
  file_format: 1
