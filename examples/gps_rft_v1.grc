options:
  parameters:
    generate_options: qt_gui
    id: gps_rft_v1
    output_language: python
    title: gps_rft_v1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/memyselfandi/projects/gnuradio/gr-gps/examples/signal.dat
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gnss_acquisition_and_tracking_0
  id: gnss_acquisition_and_tracking
  parameters:
    dll_bw_coarse: '4.0'
    dll_bw_fine: '1.0'
    identifier: '1'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: '40.0'
    pll_bw_fine: '30.0'
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    dll_bw_coarse: '4.0'
    dll_bw_fine: '1.0'
    identifier: '11'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: '40.0'
    pll_bw_fine: '30.0'
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    dll_bw_coarse: '4.0'
    dll_bw_fine: '1.0'
    identifier: '20'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: '40.0'
    pll_bw_fine: '30.0'
    sampling_freq: samp_rate
  states: {}
- name: gnss_acquisition_and_tracking_0_0_0_0
  id: gnss_acquisition_and_tracking
  parameters:
    dll_bw_coarse: '4.0'
    dll_bw_fine: '1.0'
    identifier: '32'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: '40.0'
    pll_bw_fine: '30.0'
    sampling_freq: samp_rate
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_ca_sybmols_to_nav_bits_0_0_0_0
  id: gnss_ca_sybmols_to_nav_bits
  parameters: {}
  states: {}
- name: gnss_geojson_file_sink_1
  id: gnss_geojson_file_sink
  parameters:
    filename: '"default"'
  states: {}
- name: gnss_nav_message_decoder_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '1'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_nav_message_decoder_0_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '11'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_nav_message_decoder_0_0_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '20'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_nav_message_decoder_0_0_0_0
  id: gnss_nav_message_decoder
  parameters:
    identifier: '32'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
  states: {}
- name: gnss_pseudoranges_decoder_0
  id: gnss_pseudoranges_decoder
  parameters:
    identifier0: '1'
    identifier1: '11'
    identifier2: '20'
    identifier3: '32'
    identifier4: '-1'
    identifier5: '-1'
    identifier6: '-1'
    identifier7: '-1'
    navigation_system0: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system1: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system2: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system3: gnss.NAVIGATION_SYSTEM_GPS
    navigation_system4: gnss.NAVIGATION_SYSTEM_UNDEFINED
    navigation_system5: gnss.NAVIGATION_SYSTEM_UNDEFINED
    navigation_system6: gnss.NAVIGATION_SYSTEM_UNDEFINED
    navigation_system7: gnss.NAVIGATION_SYSTEM_UNDEFINED
    num_inputs: '4'
  states: {}
- name: gnss_pvt_0
  id: gnss_pvt
  parameters:
    num_inputs: '4'
  states: {}
- name: gnss_rft_0
  id: gnss_rft
  parameters:
    rft: gnss.RFT_ECEF_TO_GCS
  states: {}
- name: gps_acquisition_0
  id: gps_acquisition
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '4000'
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0_0_0_0, '0']
- [blocks_throttle_0, '0', gps_acquisition_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_ca_sybmols_to_nav_bits_0, '0']
- [gnss_acquisition_and_tracking_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0, '0']
- [gnss_acquisition_and_tracking_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0_0, '0', gnss_ca_sybmols_to_nav_bits_0_0_0_0, '0']
- [gnss_acquisition_and_tracking_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0, '0', gnss_nav_message_decoder_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0, '0', gnss_nav_message_decoder_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0_0, '0', gnss_nav_message_decoder_0_0_0, '0']
- [gnss_ca_sybmols_to_nav_bits_0_0_0_0, '0', gnss_nav_message_decoder_0_0_0_0, '0']
- [gnss_nav_message_decoder_0, '0', gnss_pseudoranges_decoder_0, '0']
- [gnss_nav_message_decoder_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_nav_message_decoder_0_0, '0', gnss_pseudoranges_decoder_0, '1']
- [gnss_nav_message_decoder_0_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_nav_message_decoder_0_0_0, '0', gnss_pseudoranges_decoder_0, '2']
- [gnss_nav_message_decoder_0_0_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0_0_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_nav_message_decoder_0_0_0_0, '0', gnss_pseudoranges_decoder_0, '3']
- [gnss_nav_message_decoder_0_0_0_0, clock, gnss_pseudoranges_decoder_0, clock]
- [gnss_nav_message_decoder_0_0_0_0, ephemeris, gnss_pseudoranges_decoder_0, ephemeris]
- [gnss_pseudoranges_decoder_0, '0', gnss_pvt_0, '0']
- [gnss_pseudoranges_decoder_0, '1', gnss_pvt_0, '1']
- [gnss_pseudoranges_decoder_0, '2', gnss_pvt_0, '2']
- [gnss_pseudoranges_decoder_0, '3', gnss_pvt_0, '3']
- [gnss_pvt_0, '0', gnss_rft_0, '0']
- [gnss_rft_0, '0', gnss_geojson_file_sink_1, '0']

metadata:
  file_format: 1
