options:
  parameters:
    generate_options: qt_gui
    id: gps_acquisition_and_tracking_v5
    output_language: python
    title: gps_acquisition_and_tracking_v5
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: svid
  id: variable
  parameters:
    value: '32'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: samp_rate//1000
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/memyselfandi/projects/gnss-sdr-files/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN.dat
    repeat: 'True'
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gnss_acquisition_and_tracking_0
  id: gnss_acquisition_and_tracking
  parameters:
    debug_port: 'True'
    dll_bw_coarse: '4.0'
    dll_bw_fine: '2.0'
    identifier: '32'
    navigation_system: gnss.NAVIGATION_SYSTEM_GPS
    pll_bw_coarse: '40.0'
    pll_bw_fine: '35.0'
    sampling_freq: samp_rate
  states: {}
- name: gnss_number_file_sink_0
  id: gnss_number_file_sink
  parameters:
    delimiter: '"\n"'
    filename: '"code_rate_svid_32.dat"'
    num_inputs: '1'
    type: f32
  states: {}
- name: gnss_signal_normalizer_0
  id: gnss_signal_normalizer
  parameters:
    itype: s16
    otype: fc32
    resolution: '12'
    vlen: '1'
  states: {}
- name: gnss_type_converter_0
  id: gnss_type_converter
  parameters:
    itype: fc64
    otype: fc32
    vlen: '1'
  states: {}
- name: gnss_type_converter_0_0
  id: gnss_type_converter
  parameters:
    itype: fc64
    otype: fc32
    vlen: '1'
  states: {}
- name: gps_acquisition_0
  id: gps_acquisition
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    marker1: '0'
    marker2: '0'
    size: '200'
    srate: samp_rate / 4000
    type: complex
    ymax: '200000'
    ymin: '-200000'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '200'
    srate: samp_rate / 4000
    type: float
    ymax: 1023000+20
    ymin: 1023000-20
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', gnss_number_file_sink_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_file_source_0, '0', gnss_signal_normalizer_0, '0']
- [blocks_throttle_0, '0', gnss_acquisition_and_tracking_0, '0']
- [blocks_throttle_0, '0', gps_acquisition_0, '0']
- [gnss_acquisition_and_tracking_0, '0', gnss_type_converter_0, '0']
- [gnss_acquisition_and_tracking_0, '1', gnss_type_converter_0_0, '0']
- [gnss_signal_normalizer_0, '0', blocks_throttle_0, '0']
- [gnss_type_converter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [gnss_type_converter_0_0, '0', blocks_complex_to_imag_0, '0']

metadata:
  file_format: 1
